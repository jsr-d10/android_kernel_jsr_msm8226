## drivers/exfat/Kconfig
```kconfig
#
# exFAT filesystem
#
menuconfig EXFAT_DRV
	bool "exFAT filesystem support"
  default n
```
